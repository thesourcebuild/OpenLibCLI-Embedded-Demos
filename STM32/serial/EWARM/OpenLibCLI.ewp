# IAR project OpenLibCLI.ewp, settings and files
configuration OpenLibCLI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Core\Src\OpenLibCLI\config; ..\Core\Src\OpenLibCLI\utils; ..\Core\Src\OpenLibCLI
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenLibCLI.hex
  ILINK.IlinkOutputFile: OpenLibCLI.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: cli_demo_setup.c cli_demo_setup.h cli_transport_serial.c cli_transport_serial.h main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/User/Core/OpenLibCLI
    ../Core/Src/OpenLibCLI/: cli.c cli.h cli_env_detect.h cli_version.h
  group Application/User/Core/OpenLibCLI/config
    ../Core/Src/OpenLibCLI/config/: cli_config.h
  group Application/User/Core/OpenLibCLI/utils
    ../Core/Src/OpenLibCLI/utils/: cli_args_parse.c cli_args_parse.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
